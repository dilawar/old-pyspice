Usefulness of Decap in reducing Interconnect Inductances
*
*===================================================================
* DC Supply
vdc supply gnd dc 1v
*
*===================================================================
* Wire Description
R_dd supply L1_plus 0.05
L_dd L1_plus Sys_plus 0.1e-15
L_ss L2_minus Sys_minus 0.1e-15
R_ss L2_minus gnd 0.05
*
*===================================================================
* System Description
ipwl Sys_plus node1 pwl(0 0 500ps 0 550ps 10 600ps 0 1500ps 0 1550ps 10 1600ps 0 2500ps 0 2550ps 10 2600ps 0 3500ps 0  3550ps 10 3600ps 0 4500ps 0 4550ps 10 4600ps 0 5500ps 0 5550ps 10 5600ps 0 6500ps 0  6550ps 10 6600ps 0 7500ps 0 7550ps 10 7600ps 0 8500ps 0 8550ps 10 8600ps 0 9500ps 0 9550ps 10 9600ps 0 10500ps 0 10550ps 10 10600ps 0 11500ps 0 11550ps 10 11600ps 0 12500ps 0 12550ps 10 12600ps 0 13500ps 0 13550ps 10 13600ps 0 14500ps 0 14550ps 10 14600ps 0 15500ps 0 15550ps 10 15600ps 0 16500ps 0 16550ps 10 16600ps 0 17500ps 0 17550ps 10 17600ps 0 18500ps 0 18550ps 10 18600ps 0 19500ps 0 19550ps 10 19600ps 0 20500ps 0 20550ps 10 20600ps 0 21500ps 0 21550ps 10 21600ps 0 22500ps 0 22550ps 10 22600ps 0 23500ps 0 23550ps 10 23600ps 0 24500ps 0 24550ps 10 24600ps 0 25500ps 0 25550ps 10 25600ps 0 26500ps 0 26550ps 10 26600ps 0 27500ps 0 27550ps 10 27600ps 0 28500ps 0 28550ps 10 28600ps 0 29500ps 0 29550ps 10 29600ps 0 30500ps 0 30550ps 10 30600ps 0 31500ps 0 31550ps 10 31600ps 0 32500ps 0 32550ps 10 32600ps 0 33500ps 0 33550ps 10 33600ps 0 34500ps 0 34550ps 10 34600ps 0 35500ps 0 35550ps 10 35600ps 0 36500ps 0 36550ps 10 36600ps 0 37500ps 0 37550ps 10 37600ps 0 38500ps 0 38550ps 10 38600ps 0 39500ps 0 39550ps 10 39600ps 0 40500ps 0 40550ps 10 40600ps 0 41500ps 0 41550ps 10 41600ps 0 42500ps 0 42550ps 10 42600ps 0 43500ps 0 43550ps 10 43600ps 0 44500ps 0 44550ps 10 44600ps 0 45500ps 0 45550ps 10 45600ps 0 46500ps 0 46550ps 10 46600ps 0 47500ps 0 47550ps 10 47600ps 0 48500ps 0 48550ps 10 48600ps 0 49500ps 0 49550ps 10 49600ps 0 50500ps 0 50550ps 10 50600ps 0 51500ps 0 51550ps 10 51600ps 0 52500ps 0 52550ps 10 52600ps 0 53500ps 0 53550ps 10 53600ps 0 54500ps 0 54550ps 10 54600ps 0 55500ps 0 55550ps 10 55600ps 0 56500ps 0 56550ps 10 56600ps 0 57500ps 0 57550ps 10 57600ps 0 58500ps 0 58550ps 10 58600ps 0 59500ps 0 59550ps 10 59600ps 0 60500ps 0 60550ps 10 60600ps 0 61500ps 0 61550ps 10 61600ps 0 62500ps 0 62550ps 10 62600ps 0 63500ps 0 63550ps 10 63600ps 0 64500ps 0 64550ps 10 64600ps 0 65500ps 0 65550ps 10 65600ps 0 66500ps 0 66550ps 10 66600ps 0 67500ps 0 67550ps 10 67600ps 0 68500ps 0 68550ps 10 68600ps 0 69500ps 0 69550ps 10 69600ps 0 70500ps 0 70550ps 10 70600ps 0 71500ps 0 71550ps 10 71600ps 0 72500ps 0 72550ps 10 72600ps 0 73500ps 0 73550ps 10 73600ps 0 74500ps 0 74550ps 10 74600ps 0 75500ps 0 75550ps 10 75600ps 0 76500ps 0 76550ps 10 76600ps 0 77500ps 0 77550ps 10 77600ps 0 78500ps 0 78550ps 10 78600ps 0 79500ps 0 79550ps 10 79600ps 0 80500ps 0 80550ps 10 80600ps 0 81500ps 0 81550ps 10 81600ps 0 82500ps 0 82550ps 10 82600ps 0 83500ps 0 83550ps 10 83600ps 0 84500ps 0 84550ps 10 84600ps 0 85500ps 0 85550ps 10 85600ps 0 86500ps 0 86550ps 10 86600ps 0 87500ps 0 87550ps 10 87600ps 0 88500ps 0 88550ps 10 88600ps 0 89500ps 0 89550ps 10 89600ps 0 90500ps 0)
vmeasure node1 node2 dc 0v
C_L node2 Sys_minus 0.5n
*
*===================================================================
* Decoupling Capacitance
Cdecap Sys_plus Sys_minus 49.5n
*
*===================================================================
* Transient Analysis upto 90ns, in steps of 0.01ns
.ic v(Sys_plus)=0v v(Sys_minus)=0v
.tran 0.01ns 90ns uic
*
*===================================================================
* .control section
.control
run
plot v(Sys_plus) - v(Sys_minus)
plot i(vmeasure)
.endc
* end of control section
*===================================================================
* End Simulation
.end
*===================================================================
