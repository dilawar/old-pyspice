Assignment 2 Question3b
*****************************INDUCTANCES*************************
L1 1 2 193.6n
L3 4 5 193.6n
L4 7 6 193.6n
L2 0 6 193.6n

*****************************MUTUAL INDUCTANCES******************

K13 L1 L3 0.1543
K14 L1 L4 0.1543
K12 L1 L2 0.1
K23 L2 L3 0.1543
K24 L2 L4 0.1543
K34 L3 L4 0.846

*****************************CAPACITANCES**********************

C131 1 4 227.73f
C132 2 5 227.73f
C341 5 0 5.26p
C342 5 6 5.26p

****************************RESISTANCES**************************

R1 3 4 10
R2 7 0 0
C1 2 5 0.1n
C2 5 6 0.1n

***************************SOURCES*********************************

Vdd 1 0 dc 1v
Vr 3 0 pwl(0 0v 1ns 1v 3us 1v)

.control
tran 0.01ns 1us
plot v(2)
plot v(6)
write a2q3b_vdd.raw v(2)
write a2q3b_gnd.raw v(6)
.endc
