Assignment 2 Question3c
*************************INDUCTANCES************************
L1 1 2 193.6n
L3 4 5 193.6n
L4 9 7 193.6n
L2 0 6 193.6n

*********************MUTUAL INDUCTANCES**********************

K13 L1 L3 0.1543
K14 L1 L4 0.1543
K12 L1 L2 0.1
K23 L2 L3 0.1543
K24 L2 L4 0.1543
K34 L3 L4 0.846

***********************CAPACITANCES**************************

C131 1 4 227.73f
C132 2 5 227.73f
C241 9 0 227.73f
C242 7 6 227.73f
C341 4 9 5.26pF
C342 5 7 5.26pF

************************RESISTORS****************************

R1 3 4 10
R2 8 9 10
C1 2 5 0.1n
C2 5 6 0.1n
C3 2 7 0.1n
C4 7 6 0.1n

*************************SOURCES******************************

Vdd 1 0 dc 1v
Vr1 1 3 pwl(0 0v 1ns 1v 3us 1v)
Vr2 8 0 pwl(0 0v 1ns 1v 3us 1v)

.control
tran 0.01ns 1u
plot v(2)
plot v(6)
write a2q3c_vdd.raw v(2)
write a2q3c_gnd.raw v(2)
.endc
