*differential signal

VDD a 0 DC 1V

Vr1 a g PWL(0 0 1ns 1v 20ns 1v 20us 1v)
Vr2 i 0 PWL(0 0 1ns 1v 20ns 1v 20us 1v)

R1 g f 10
R2 i h 10

C1 b e 0.1nF
C2 e d 0.1nF
C3 b c 0.1nF
C4 c d 0.1nF
C13 b e 104.75fF
C34 e c 2.62pF
C42 c d 104.75fF

L11 a b 195nH
L33 f e 195nH
L44 h c 195nH
L22 0 d 195nH
K13 L11 L33 0.152
K14 L11 L44 0.152
K12 L11 L22 0.0996
K34 L33 L44 0.837
K32 L33 L22 0.152
K42 L44 L22 0.152

.control
tran 0.1ns 1us
run
plot v(b)
plot v(d)

.endc
