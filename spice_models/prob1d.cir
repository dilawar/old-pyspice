.include tsmc_spice_180nm.txt

*resistance
R1 1 2 0.05
R2 5 0 0.05

*inductance
L1 2 3 1pH
L2 4 5 1pH

*decoupling capacitance
C1 3 4 99nF

*dc source
V1 1 0 dc 1V

*modelling the system as a current source
I1 3 7 pwl ( 0ns 0A 50ps 0A 100ps 0A 2ns 0A 2.05ns 20A 2.1ns 0A 4ns 0A 4.05ns 20A 4.1ns 0A 6ns 0A 6.05ns 20A 6.1ns 0A 8ns 0A 8.05ns 20A 8.1ns 0A 10ns 0A 10.05ns 20A 10.1ns 0A 12ns 0A 12.05ns 20A 12.1ns 0A  14ns 0A 14.05ns 20A 14.1ns 0A 16ns 0A 16.05ns 20A 16.1ns 0A 18ns 0A 18.05ns 20A 18.1ns 0A 20ns 0A 20.05ns 20A 20.1ns 0A 22ns 0A 22.05ns 20A 22.1ns 0A 24ns 0A 24.05ns 20A 24.1ns 0A 26ns 0A 26.05ns 20A 26.1ns 0A 28ns 0A 28.05ns 20A 28.1ns 0A 30ns 0A 30.05ns 20A 30.1ns 0A 32ns 0A 32.05ns 20A 32.1ns 0A 34ns 0A 34.05ns 20A 34.1ns 0A 36ns 0A 36.05ns 20A 36.1ns 0A 38ns 0A 38.05ns 20A 38.1ns 0A 40ns 0A 40.05ns 20A 40.1ns 0A 42ns 0A 42.05ns 20A 42.1ns 0A 44ns 0A 44.05ns 20A 44.1ns 0A 46ns 0A 46.05ns 20A 46.1ns 0A 48ns 0A 48.05ns 20A 48.1ns 0A 50ns 0A 50.05ns 20A 50.1ns 0A 52ns 0A 52.05ns 20A 52.1ns 0A 54ns 0A 54.05ns 20A 54.1ns 0A 56ns 0A 56.05ns 20A 56.1ns 0A 58ns 0A 58.05ns 20A 58.1ns 0A 60ns 0A 60.05ns 20A 60.1ns 0A 62ns 0A 62.05ns 20A 62.1ns 0A 64ns 0A 64.05ns 20A 64.1ns 0A 66ns 0A 66.05ns 20A 66.1ns 0A 68ns 0A 68.05ns 20A 68.1ns 0A 70ns 0A 70.05ns 20A 70.1ns 0A 72ns 0A 72.05ns 20A 72.1ns 0A 74ns 0A 74.05ns 20A 74.1ns 0A 76ns 0A 76.05ns 20A 76.1ns 0A 78ns 0A 78.05ns 20A 78.1ns 0A 80ns 0A 80.05ns 20A 80.1ns 0A 82ns 0A 82.05ns 20A 82.1ns 0A 84ns 0A 84.05ns 20A 84.1ns 0A 86ns 0A 86.05ns 20A 86.1ns 0A 88ns 0A 88.05ns 20A 88.1ns 0A 90ns 0A 90.05ns 20A 90.1ns 0A 92ns 0A 92.05ns 20A 92.1ns 0A 94ns 0A 94.05ns 20A 94.1ns 0A 96ns 0A 96.05ns 20A 96.1ns 0A 98ns 0A 98.05ns 20A 98.1ns 0A 100ns 0A 100.05ns 20A 100.1ns 0A 102ns 0A  102.05ns 20A 102.1ns 0A 104ns 0A 104.05ns 20A 104.1ns 0A 106ns 0A 106.05ns 20A 106.1ns 0A 108ns 0A 108.05ns 20A 108.1ns 0A 110ns 0A 110.05ns 20A 110.1ns 0A 112ns 0A 112.05ns 20A 112.1ns 0A  114ns 0A 114.05ns 20A 114.1ns 0A 116ns 0A 116.05ns 20A 116.1ns 0A 118ns 0A 118.05ns 20A 118.1ns 0A 120ns 0A 120.05ns 20A 120.1ns 0A 122ns 0A 122.05ns 20A 122.1ns 0A 124ns 0A 124.05ns 20A 124.1ns 0A 126ns 0A 126.05ns 20A 126.1ns 0A 128ns 0A 128.05ns 20A 128.1ns 0A 130ns 0A 130.05ns 20A 130.1ns 0A 132ns 0A 132.05ns 20A 132.1ns 0A 134ns 0A 134.05ns 20A 134.1ns 0A 136ns 0A 136.05ns 20A 136.1ns 0A 138ns 0A 138.05ns 20A 138.1ns 0A 140ns 0A 140.05ns 20A 140.1ns 0A 142ns 0A 142.05ns 20A 142.1ns 0A 144ns 0A 144.05ns 20A 144.1ns 0A 146ns 0A 146.05ns 20A 146.1ns 0A 148ns 0A 148.05ns 20A 148.1ns 0A 150ns 0A 150.05ns 20A 150.1ns 0A 152ns 0A 152.05ns 20A 152.1ns 0A 154ns 0A 154.05ns 20A 154.1ns 0A 156ns 0A 156.05ns 20A 156.1ns 0A 158ns 0A 158.05ns 20A 158.1ns 0A 160ns 0A 160.05ns 20A 160.1ns 0A 162ns 0A 162.05ns 20A 162.1ns 0A 164ns 0A 164.05ns 20A 164.1ns 0A 166ns 0A 166.05ns 20A 166.1ns 0A 168ns 0A 168.05ns 20A 168.1ns 0A 170ns 0A 170.05ns 20A 170.1ns 0A 172ns 0A 172.05ns 20A 172.1ns 0A 174ns 0A 174.05ns 20A 174.1ns 0A 176ns 0A 176.05ns 20A 176.1ns 0A 178ns 0A 178.05ns 20A 178.1ns 0A 180ns 0A 180.05ns 20A 180.1ns 0A 182ns 0A 182.05ns 20A 182.1ns 0A 184ns 0A 184.05ns 20A 184.1ns 0A 186ns 0A 186.05ns 20A 186.1ns 0A 188ns 0A 188.05ns 20A 188.1ns 0A 190ns 0A 190.05ns 20A 190.1ns 0A 192ns 0A 192.05ns 20A 192.1ns 0A 194ns 0A 194.05ns 20A 194.1ns 0A 196ns 0A 196.05ns 20A 196.1ns 0A 198ns 0A 198.05ns 20A 198.1ns 0A 200ns 0A )

*V2 10 0 dc 0V
*source to measure current
V3 7 8 dc 0V

*load capacitance
C2 8 4 1nF

*initial condition
.ic v(3)=1 v(4)=0

.tran 10ps 200ns  uic
.control
run
plot v(3)-v(4)
plot i(v3)
.endc

.end
