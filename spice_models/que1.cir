Modelling the system and seeing the variation of the inductor

c1 7 5 0.5nf
c2 3 5 49.5nf
R1 2 3 50m
R2 6 5 50m

L1 1 2 1pH
L2 0 6 1pH

vdd 1 0 1v

Vp 8 0 pwl (0 0 200ps 0 250ps 10v 300ps 0 1200ps 0 1250ps 10v 1300ps 0 2200ps 0 2250ps 10v 2300ps 0 3200ps 0 3250ps 10v 3300ps 0 4200ps 0 4250ps 10v 4300ps 0 5200ps 0 5250ps 10v 5300ps 0 6200ps 0 6250ps 10v 6300ps 0 7200ps 0 7250ps 10v 7300ps 0 8200ps 0 8250ps 10v 8300ps 0 9200ps 0 9250ps 10v 9300ps 0 10200ps 0 10250ps 10v 10300ps 0 11200ps 0 11250ps 10v 11300ps 0 12200ps 0 12250ps 10v 12300ps 0 13200ps 0 13250ps 10v 13300ps 0 14200ps 0 14250ps 10v 14300ps 0 15200ps 0 15250ps 10v 15300ps 0 16200ps 0 16250ps 10v 16300ps 0 17200ps 0 17250ps 10v 17300ps 0 18200ps 0 18250ps 10v 18300ps 0 19200ps 0 19250ps 10v 19300ps 0 20200ps 0 20250ps 10v 20300ps 0 21200ps 0 21250ps 10v 21300ps 0 22200ps 0 22250ps 10v 22300ps 0 23200ps 0 23250ps 10v 23300ps 0 24200ps 0 24250ps 10v 24300ps 0 25200ps 0 25250ps 10v 25300ps 0 26200ps 0 26250ps 10v 26300ps 0 27200ps 0 27250ps 10v 27300ps 0 28200ps 0 28250ps 10v 28300ps 0 29200ps 0 29250ps 10v 29300ps 0 30200ps 0 30250ps 10v 30300ps 0 31200ps 0 31250ps 10v 31300ps 0 32200ps 0 32250ps 10v 32300ps 0 33200ps 0 33250ps 10v 33300ps 0 34200ps 0 34250ps 10v 34300ps 0 35200ps 0 35250ps 10v 35300ps 0 36200ps 0 36250ps 10v 36300ps 0 37200ps 0 37250ps 10v 37300ps 0 38200ps 0 38250ps 10v 38300ps 0 39200ps 0 39250ps 10v 39300ps 0 40200ps 0 40250ps 10v 40300ps 0 41200ps 0 41250ps 10v 41300ps 0 42200ps 0 42250ps 10v 42300ps 0 43200ps 0 43250ps 10v 43300ps 0 44200ps 0 44250ps 10v 44300ps 0 45200ps 0 45250ps 10v 45300ps 0 46200ps 0 46250ps 10v 46300ps 0 47200ps 0 47250ps 10v 47300ps 0 48200ps 0 48250ps 10v 48300ps 0 49200ps 0 49250ps 10v 49300ps 0 50200ps 0 50250ps 10v 50300ps 0 51200ps 0 51250ps 10v 51300ps 0 52200ps 0 52250ps 10v 52300ps 0 53200ps 0 53250ps 10v 53300ps 0 54200ps 0 54250ps 10v 54300ps 0 55200ps 0 55250ps 10v 55300ps 0 56200ps 0 56250ps 10v 56300ps 0 57200ps 0 57250ps 10v 57300ps 0 58200ps 0 58250ps 10v 58300ps 0 59200ps 0 59250ps 10v 59300ps 0 60200ps 0 60250ps 10v 60300ps 0 61200ps 0 61250ps 10v 61300ps 0 62200ps 0 62250ps 10v 62300ps 0 63200ps 0 63250ps 10v 63300ps 0 64200ps 0 64250ps 10v 64300ps 0 65200ps 0 65250ps 10v 65300ps 0 66200ps 0 66250ps 10v 66300ps 0 67200ps 0 67250ps 10v 67300ps 0 68200ps 0 68250ps 10v 68300ps 0 69200ps 0 69250ps 10v 69300ps 0)

Vq 9 0 pwl (0 0 700ps 0 750ps 10v 800ps 0 1700ps 0 1750ps 10v 1800ps 0 2700ps 0 2750ps 10v 2800ps 0 3700ps 0 3750ps 10v 3800ps 0 4700ps 0 4750ps 10v 4800ps 0 5700ps 0 5750ps 10v 5800ps 0 6700ps 0 6750ps 10v 6800ps 0 7700ps 0 7750ps 10v 7800ps 0 8700ps 0 8750ps 10v 8800ps 0 9700ps 0 9750ps 10v 9800ps 0 10700ps 0 10750ps 10v 10800ps 0 11700ps 0 11750ps 10v 11800ps 0 12700ps 0 12750ps 10v 12800ps 0 13700ps 0 13750ps 10v 13800ps 0 14700ps 0 14750ps 10v 14800ps 0 15700ps 0 15750ps 10v 15800ps 0 16700ps 0 16750ps 10v 16800ps 0 17700ps 0 17750ps 10v 17800ps 0 18700ps 0 18750ps 10v 18800ps 0 19700ps 0 19750ps 10v 19800ps 0 20700ps 0 20750ps 10v 20800ps 0 21700ps 0 21750ps 10v 21800ps 0 22700ps 0 22750ps 10v 22800ps 0 23700ps 0 23750ps 10v 23800ps 0 24700ps 0 24750ps 10v 24800ps 0 25700ps 0 25750ps 10v 25800ps 0 26700ps 0 26750ps 10v 26800ps 0 27700ps 0 27750ps 10v 27800ps 0 28700ps 0 28750ps 10v 28800ps 0 29700ps 0 29750ps 10v 29800ps 0 30700ps 0 30750ps 10v 30800ps 0 31700ps 0 31750ps 10v 31800ps 0 32700ps 0 32750ps 10v 32800ps 0 33700ps 0 33750ps 10v 33800ps 0 34700ps 0 34750ps 10v 34800ps 0 35700ps 0 35750ps 10v 35800ps 0 36700ps 0 36750ps 10v 36800ps 0 37700ps 0 37750ps 10v 37800ps 0 38700ps 0 38750ps 10v 38800ps 0 39700ps 0 39750ps 10v 39800ps 0 40700ps 0 40750ps 10v 40800ps 0 41700ps 0 41750ps 10v 41800ps 0 42700ps 0 42750ps 10v 42800ps 0 43700ps 0 43750ps 10v 43800ps 0 44700ps 0 44750ps 10v 44800ps 0 45700ps 0 45750ps 10v 45800ps 0 46700ps 0 46750ps 10v 46800ps 0 47700ps 0 47750ps 10v 47800ps 0 48700ps 0 48750ps 10v 48800ps 0 49700ps 0 49750ps 10v 49800ps 0 50700ps 0 50750ps 10v 50800ps 0 51700ps 0 51750ps 10v 51800ps 0 52700ps 0 52750ps 10v 52800ps 0 53700ps 0 53750ps 10v 53800ps 0 54700ps 0 54750ps 10v 54800ps 0 55700ps 0 55750ps 10v 55800ps 0 56700ps 0 56750ps 10v 56800ps 0 57700ps 0 57750ps 10v 57800ps 0 58700ps 0 58750ps 10v 58800ps 0 59700ps 0 59750ps 10v 59800ps 0 60700ps 0 60750ps 10v 60800ps 0 61700ps 0 61750ps 10v 61800ps 0 62700ps 0 62750ps 10v 62800ps 0 63700ps 0 63750ps 10v 63800ps 0 64700ps 0 64750ps 10v 64800ps 0 65700ps 0 65750ps 10v 65800ps 0 66700ps 0 66750ps 10v 66800ps 0 67700ps 0 67750ps 10v 67800ps 0 68700ps 0 68750ps 10v 68800ps 0 69200ps 0 69750ps 10v 69800ps 0)

G1 3 4 8 0 1
G2 4 5 9 0 1
V3 4 7 0v

R7 8 0 1
R8 9 0 1

*.ic v(3)=1v
.tran 0.2ns 70ns uic

.control

run

plot v(3)-v(5)
plot I(V3)

.endc
.end
